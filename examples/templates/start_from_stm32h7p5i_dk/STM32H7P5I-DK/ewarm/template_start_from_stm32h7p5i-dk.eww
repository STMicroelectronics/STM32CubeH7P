<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\template_start_from_stm32h7p5i-dk.ewp</path>
    </project>
</workspace>
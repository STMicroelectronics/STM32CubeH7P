# IAR project template_start_from_stm32h7p5i-dk.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32H7P5II ST STM32H7P5II
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7P5xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_STM32H7P5I-DK/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../part_drivers/button/gpio; ../../../../../../part_drivers/led/gpio; ../../../../../../part_drivers/mx25lm51245g; ../../../../../../part_drivers/potentiometer/adc; ../../../../../../part_drivers/st7315; ../../../../../../part_drivers/st7315/interfaces/spi; ../../../../../../part_drivers/tcpp01; ../../../../../../part_drivers/tcpp01/interfaces/adc_exti; ../../../../../../stm32h7pxx_dfp/Include; ../../../../../../stm32h7pxx_drivers/hal; ../../../../../../stm32h7pxx_drivers/ll; ../../../../../../stm32h7pxx_drivers/timebases; ../../../../../../utilities/basic_stdio; ../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/parts/button; ../../generated/parts/led; ../../generated/parts/mx25lm51245g; ../../generated/parts/potentiometer; ../../generated/parts/st7315; ../../generated/parts/tcpp01; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_STM32H7P5I-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32H7P5xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32H7P5IIK6Q/stm32h7p5xi_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_adc1.c mx_adc1.h mx_adc2.c mx_adc2.h mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_cortex_scb.c mx_cortex_scb.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_pwr.c mx_pwr.h mx_rcc.c mx_rcc.h mx_spi1.c mx_spi1.h mx_system.c mx_system.h mx_usart2.c mx_usart2.h mx_xspi1.c mx_xspi1.h stm32_external_env.h stm32h7pxx_hal_conf.h
  group generated/parts/button
    ../../generated/parts/button/: mx_button.c mx_button.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/parts/mx25lm51245g
    ../../generated/parts/mx25lm51245g/: mx_mx25lm51245g.c mx_mx25lm51245g.h
  group generated/parts/potentiometer
    ../../generated/parts/potentiometer/: mx_potentiometer.c mx_potentiometer.h
  group generated/parts/st7315
    ../../generated/parts/st7315/: mx_st7315.c mx_st7315.h
  group generated/parts/tcpp01
    ../../generated/parts/tcpp01/: mx_tcpp01.c mx_tcpp01.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group part_drivers/button
    ../../../../../../part_drivers/button/: README.md SW_Security_Level.md
  group part_drivers/button/gpio
    ../../../../../../part_drivers/button/gpio/: button.c button.h
  group part_drivers/led
    ../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../part_drivers/led/gpio/: led.h
  group part_drivers/mx25lm51245g
    ../../../../../../part_drivers/mx25lm51245g/: mx25lm51245g.c mx25lm51245g.h README.md SW_Security_Level.md
  group part_drivers/potentiometer
    ../../../../../../part_drivers/potentiometer/: README.md SW_Security_Level.md
  group part_drivers/potentiometer/adc
    ../../../../../../part_drivers/potentiometer/adc/: potentiometer.c potentiometer.h
  group part_drivers/st7315
    ../../../../../../part_drivers/st7315/: README.md Release_Notes.md st7315.c st7315.h SW_Security_Level.md
  group part_drivers/st7315/interfaces/spi
    ../../../../../../part_drivers/st7315/interfaces/spi/: st7315_io.c st7315_io.h
  group part_drivers/tcpp01
    ../../../../../../part_drivers/tcpp01/: README.md SW_Security_Level.md tcpp01.c tcpp01.h
  group part_drivers/tcpp01/interfaces/adc_exti
    ../../../../../../part_drivers/tcpp01/interfaces/adc_exti/: tcpp01_io.c tcpp01_io.h
  group stm32h7pxx_dfp
    ../../../../../../stm32h7pxx_dfp/: README.md
  group stm32h7pxx_dfp/Include
    ../../../../../../stm32h7pxx_dfp/Include/: stm32h7pxx.h
  group stm32h7pxx_drivers
    ../../../../../../stm32h7pxx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32h7pxx_drivers/doc
    ../../../../../../stm32h7pxx_drivers/doc/: STMicroelectronics.stm32h7pxx_hal_drivers_dependencies.md
  group stm32h7pxx_drivers/hal
    ../../../../../../stm32h7pxx_drivers/hal/: stm32_hal.h stm32h7pxx_dlyb_core.c stm32h7pxx_dlyb_core.h stm32h7pxx_hal_adc.c stm32h7pxx_hal_adc.h stm32h7pxx_hal_cortex.c stm32h7pxx_hal_cortex.h stm32h7pxx_hal_def.h stm32h7pxx_hal_dma.c stm32h7pxx_hal_dma.h stm32h7pxx_hal_exti.c stm32h7pxx_hal_exti.h stm32h7pxx_hal_flash_itf.c stm32h7pxx_hal_flash_itf.h stm32h7pxx_hal_gpio.c stm32h7pxx_hal_gpio.h stm32h7pxx_hal_pwr.c stm32h7pxx_hal_pwr.h stm32h7pxx_hal_q.c stm32h7pxx_hal_q.h stm32h7pxx_hal_rcc.c stm32h7pxx_hal_rcc.h stm32h7pxx_hal_sbs.c stm32h7pxx_hal_sbs.h stm32h7pxx_hal_spi.c stm32h7pxx_hal_spi.h stm32h7pxx_hal_uart.c stm32h7pxx_hal_uart.h stm32h7pxx_hal_xspi.c stm32h7pxx_hal_xspi.h stm32h7pxx_hal.c stm32h7pxx_hal.h
  group stm32h7pxx_drivers/ll
    ../../../../../../stm32h7pxx_drivers/ll/: stm32h7pxx_ll_adc.h stm32h7pxx_ll_bus.h stm32h7pxx_ll_dbgmcu.h stm32h7pxx_ll_dma.h stm32h7pxx_ll_exti.h stm32h7pxx_ll_flash.h stm32h7pxx_ll_gpio.h stm32h7pxx_ll_pwr.h stm32h7pxx_ll_rcc.h stm32h7pxx_ll_sbs.h stm32h7pxx_ll_spi.h stm32h7pxx_ll_usart.h stm32h7pxx_ll_utils.h
  group user_modifiable/Device/STM32H7P5IIK6Q
    ../../user_modifiable/Device/STM32H7P5IIK6Q/: startup_stm32h7p5xx.c system_stm32h7pxx.c
  group UserCode
    ../../../application/: main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c

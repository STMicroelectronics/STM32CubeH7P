# IAR project ll_dac_signal_generation_dma_silent_tim.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32H7P5II ST STM32H7P5II
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7P5xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_STM32H7P5I-DK/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../stm32h7pxx_dfp/Include; ../../../../../../../stm32h7pxx_drivers/ll; ../../../application; ../../generated/hal; ../../user_modifiable/_release_IAR_STM32H7P5I-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32H7P5xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32H7P5IIK6Q/stm32h7p5xi_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_cortex_scb.c mx_cortex_scb.h mx_dac1.c mx_dac1.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_pwr.c mx_pwr.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_tim6.c mx_tim6.h stm32_external_env.h stm32_ll.h
  group stm32h7pxx_dfp
    ../../../../../../../stm32h7pxx_dfp/: README.md
  group stm32h7pxx_dfp/Include
    ../../../../../../../stm32h7pxx_dfp/Include/: stm32h7pxx.h
  group stm32h7pxx_drivers/ll
    ../../../../../../../stm32h7pxx_drivers/ll/: stm32h7pxx_ll_bus.h stm32h7pxx_ll_dac.h stm32h7pxx_ll_dma.h stm32h7pxx_ll_exti.h stm32h7pxx_ll_flash.h stm32h7pxx_ll_gpio.h stm32h7pxx_ll_pwr.h stm32h7pxx_ll_rcc.h stm32h7pxx_ll_sbs.h stm32h7pxx_ll_tim.h stm32h7pxx_ll_utils.h
  group user_modifiable/Device/STM32H7P5IIK6Q
    ../../user_modifiable/Device/STM32H7P5IIK6Q/: startup_stm32h7p5xx.c system_stm32h7pxx.c
  group UserCode
    ../../../application/: example.c example.h ll_example.h main.c main.h stm32h7pxx_ll_example.c
    ../../../: README.md

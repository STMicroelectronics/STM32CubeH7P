# IAR project stcryptolib_sign_verify_ecc_ecdsa.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32H7P5II ST STM32H7P5II
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7P5xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_STM32H7P5I-DK/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/stcryptolib/include; ../../../../../../../middleware/stcryptolib/include/cipher; ../../../../../../../middleware/stcryptolib/include/drbg; ../../../../../../../middleware/stcryptolib/include/ecc; ../../../../../../../middleware/stcryptolib/include/hash; ../../../../../../../middleware/stcryptolib/include/hbs; ../../../../../../../middleware/stcryptolib/include/kdf; ../../../../../../../middleware/stcryptolib/include/mac; ../../../../../../../middleware/stcryptolib/include/pqc; ../../../../../../../middleware/stcryptolib/include/rsa; ../../../../../../../middleware/stcryptolib/include/utils; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32h7pxx_dfp/Include; ../../../../../../../stm32h7pxx_drivers/hal; ../../../../../../../stm32h7pxx_drivers/ll; ../../../../../../../stm32h7pxx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/middleware/stcryptolib; ../../generated/parts/led; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_STM32H7P5I-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32H7P5xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32H7P5IIK6Q/stm32h7p5xi_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_cortex_scb.c mx_cortex_scb.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_pwr.c mx_pwr.h mx_rcc.c mx_rcc.h mx_rng.c mx_rng.h mx_system.c mx_system.h mx_usart2.c mx_usart2.h stm32h7pxx_hal_conf.h
  group generated/middleware/stcryptolib
    ../../generated/middleware/stcryptolib/: mx_cmox_config.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group middleware/stcryptolib
    ../../../../../../../middleware/stcryptolib/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group middleware/stcryptolib/include
    ../../../../../../../middleware/stcryptolib/include/: cmox_common.h cmox_crypto.h cmox_cta.h cmox_default_config.h cmox_default_defs.h cmox_info.h cmox_init.h cmox_low_level.h
  group middleware/stcryptolib/include/cipher
    ../../../../../../../middleware/stcryptolib/include/cipher/: cmox_blockcipher.h cmox_cbc.h cmox_ccm.h cmox_cfb.h cmox_chacha20.h cmox_chachapoly.h cmox_check_default_aes.h cmox_check_default_gcm.h cmox_cipher_retvals.h cmox_cipher.h cmox_ctr.h cmox_ecb.h cmox_gcm.h cmox_keywrap.h cmox_ofb.h cmox_xts.h
  group middleware/stcryptolib/include/drbg
    ../../../../../../../middleware/stcryptolib/include/drbg/: cmox_ctr_drbg.h cmox_drbg_retvals.h cmox_drbg.h
  group middleware/stcryptolib/include/ecc
    ../../../../../../../middleware/stcryptolib/include/ecc/: cmox_ecc_custom_curves.h cmox_ecc_retvals.h cmox_ecc_types.h cmox_ecc.h cmox_ecdh.h cmox_ecdsa.h cmox_eddsa.h cmox_sm2.h
  group middleware/stcryptolib/include/hash
    ../../../../../../../middleware/stcryptolib/include/hash/: cmox_hash_retvals.h cmox_hash.h cmox_md.h cmox_sha1.h cmox_sha224.h cmox_sha256.h cmox_sha3.h cmox_sha384.h cmox_sha512.h cmox_sm3.h cmox_sponge.h
  group middleware/stcryptolib/include/hbs
    ../../../../../../../middleware/stcryptolib/include/hbs/: cmox_hbs_retvals.h cmox_hbs.h
  group middleware/stcryptolib/include/kdf
    ../../../../../../../middleware/stcryptolib/include/kdf/: cmox_hkdf.h cmox_kdf_retvals.h cmox_kdf.h cmox_x963_kdf.h
  group middleware/stcryptolib/include/mac
    ../../../../../../../middleware/stcryptolib/include/mac/: cmox_cmac.h cmox_hmac.h cmox_kmac.h cmox_mac_retvals.h cmox_mac.h
  group middleware/stcryptolib/include/pqc
    ../../../../../../../middleware/stcryptolib/include/pqc/: cmox_pqc_config.h cmox_pqc_dsa.h cmox_pqc_kem.h cmox_pqc_retvals.h cmox_pqc_types.h
  group middleware/stcryptolib/include/rsa
    ../../../../../../../middleware/stcryptolib/include/rsa/: cmox_rsa_pkcs1v15.h cmox_rsa_pkcs1v22.h cmox_rsa_retvals.h cmox_rsa_types.h cmox_rsa.h
  group middleware/stcryptolib/include/utils
    ../../../../../../../middleware/stcryptolib/include/utils/: cmox_utils_compare.h cmox_utils_membuf.h cmox_utils_retvals.h
  group middleware/stcryptolib/lib
    ../../../../../../../middleware/stcryptolib/lib/: libSTM32Cryptographic_CM7.a
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32h7pxx_dfp
    ../../../../../../../stm32h7pxx_dfp/: README.md
  group stm32h7pxx_dfp/Include
    ../../../../../../../stm32h7pxx_dfp/Include/: stm32h7pxx.h
  group stm32h7pxx_drivers
    ../../../../../../../stm32h7pxx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32h7pxx_drivers/doc
    ../../../../../../../stm32h7pxx_drivers/doc/: STMicroelectronics.stm32h7pxx_hal_drivers_dependencies.md
  group stm32h7pxx_drivers/hal
    ../../../../../../../stm32h7pxx_drivers/hal/: stm32_hal.h stm32h7pxx_hal_cortex.c stm32h7pxx_hal_cortex.h stm32h7pxx_hal_def.h stm32h7pxx_hal_dma.c stm32h7pxx_hal_dma.h stm32h7pxx_hal_flash_itf.c stm32h7pxx_hal_flash_itf.h stm32h7pxx_hal_gpio.c stm32h7pxx_hal_gpio.h stm32h7pxx_hal_pwr.c stm32h7pxx_hal_pwr.h stm32h7pxx_hal_q.c stm32h7pxx_hal_q.h stm32h7pxx_hal_rcc.c stm32h7pxx_hal_rcc.h stm32h7pxx_hal_rng.c stm32h7pxx_hal_rng.h stm32h7pxx_hal_sbs.c stm32h7pxx_hal_sbs.h stm32h7pxx_hal_uart.c stm32h7pxx_hal_uart.h stm32h7pxx_hal.c stm32h7pxx_hal.h
  group stm32h7pxx_drivers/ll
    ../../../../../../../stm32h7pxx_drivers/ll/: stm32h7pxx_ll_bus.h stm32h7pxx_ll_dma.h stm32h7pxx_ll_exti.h stm32h7pxx_ll_flash.h stm32h7pxx_ll_gpio.h stm32h7pxx_ll_pwr.h stm32h7pxx_ll_rcc.h stm32h7pxx_ll_rng.h stm32h7pxx_ll_sbs.h stm32h7pxx_ll_usart.h stm32h7pxx_ll_utils.h
  group user_modifiable/Device/STM32H7P5IIK6Q
    ../../user_modifiable/Device/STM32H7P5IIK6Q/: startup_stm32h7p5xx.c system_stm32h7pxx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c

# IAR project open_bootloader_demo.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32H7P5II ST STM32H7P5II
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7P5xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-H7P5II/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/open_bootloader/core; ../../../../../../../middleware/open_bootloader/interfaces; ../../../../../../../middleware/open_bootloader/interfaces/stm32h7pxx; ../../../../../../../middleware/open_bootloader/modules; ../../../../../../../middleware/open_bootloader/modules/i2c; ../../../../../../../middleware/open_bootloader/modules/mem; ../../../../../../../middleware/open_bootloader/modules/spi; ../../../../../../../middleware/open_bootloader/modules/usart; ../../../../../../../middleware/open_bootloader/modules/usb; ../../../../../../../middleware/usbx/common/core/inc; ../../../../../../../middleware/usbx/common/usbx_device_classes/inc; ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_controllers; ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_descriptors; ../../../../../../../middleware/usbx/ports/generic/inc; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32h7pxx_dfp/Include; ../../../../../../../stm32h7pxx_drivers/hal; ../../../../../../../stm32h7pxx_drivers/ll; ../../../../../../../stm32h7pxx_drivers/timebases; ../../../application; ../../generated/hal; ../../generated/middleware/open_bootloader; ../../generated/middleware/usbx; ../../generated/parts/led; ../../user_modifiable/_release_IAR_NUCLEO-H7P5II
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32H7P5xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32H7P5IIK6/stm32h7p5xi_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_flash.c mx_flash.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_i2c3.c mx_i2c3.h mx_iwdg.c mx_iwdg.h mx_pwr.c mx_pwr.h mx_rcc.c mx_rcc.h mx_spi5.c mx_spi5.h mx_system.c mx_system.h mx_usart2.c mx_usart2.h mx_usb_otg_fs.c mx_usb_otg_fs.h stm32h7pxx_hal_conf.h
  group generated/middleware/open_bootloader
    ../../generated/middleware/open_bootloader/: mx_openbl_user.c mx_openbl_user.h mx_openbl.c mx_openbl.h openbl_conf.h
  group generated/middleware/usbx
    ../../generated/middleware/usbx/: mx_usbx_app.c mx_usbx_app.h mx_usbx_device_dfu.c mx_usbx_device_dfu.h mx_usbx_device.c mx_usbx_device.h ux_stm32_device_descriptors_config.h ux_user.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group middleware/open_bootloader
    ../../../../../../../middleware/open_bootloader/: README.md Release_Notes.md SW_Security_Level.md
  group middleware/open_bootloader/core
    ../../../../../../../middleware/open_bootloader/core/: openbl_commands.h openbl_core.c openbl_core.h openbl_interfaces.h openbl_types.h
  group middleware/open_bootloader/interfaces
    ../../../../../../../middleware/open_bootloader/interfaces/: openbl_itf_common.c openbl_itf_common.h openbl_itf_i2c.c openbl_itf_i2c.h openbl_itf_iwdg.c openbl_itf_iwdg.h openbl_itf_spi.c openbl_itf_spi.h openbl_itf_usart.c openbl_itf_usart.h openbl_itf_usb.c openbl_itf_usb.h
  group middleware/open_bootloader/interfaces/stm32h7pxx
    ../../../../../../../middleware/open_bootloader/interfaces/stm32h7pxx/: openbl_common.c openbl_hw_defs.h openbl_i2c.h openbl_itf_flash.c openbl_itf_flash.h openbl_itf_optionbytes.c openbl_itf_optionbytes.h openbl_itf_ram.c openbl_itf_ram.h openbl_itf_read_only.c openbl_itf_read_only.h openbl_spi.h openbl_usart.h openbl_usb_dfu_descriptors.c openbl_usb_dfu_descriptors.h openbl_usb_dfu.c openbl_usb_dfu.h
  group middleware/open_bootloader/modules/i2c
    ../../../../../../../middleware/open_bootloader/modules/i2c/: openbl_i2c_cmd.c openbl_i2c_cmd.h
  group middleware/open_bootloader/modules/mem
    ../../../../../../../middleware/open_bootloader/modules/mem/: openbl_mem.c openbl_mem.h
  group middleware/open_bootloader/modules/spi
    ../../../../../../../middleware/open_bootloader/modules/spi/: openbl_spi_cmd.c openbl_spi_cmd.h
  group middleware/open_bootloader/modules/usart
    ../../../../../../../middleware/open_bootloader/modules/usart/: openbl_usart_cmd.c openbl_usart_cmd.h
  group middleware/open_bootloader/modules/usb
    ../../../../../../../middleware/open_bootloader/modules/usb/: openbl_usb_cmd.c openbl_usb_cmd.h
  group middleware/usbx
    ../../../../../../../middleware/usbx/: README.md ST_Release_Notes.md SW_Security_Level.md
  group middleware/usbx/common/core/inc
    ../../../../../../../middleware/usbx/common/core/inc/: ux_api.h ux_dcd_sim_slave.h ux_device_class_dpump.h ux_device_stack.h ux_system.h ux_utility.h
  group middleware/usbx/common/core/src
    ../../../../../../../middleware/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_long_get_big_endian.c ux_utility_long_get.c ux_utility_long_put_big_endian.c ux_utility_long_put.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_allocate.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free_block_best_get.c ux_utility_memory_free.c ux_utility_memory_set.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get_big_endian.c ux_utility_short_get.c ux_utility_short_put_big_endian.c ux_utility_short_put.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group middleware/usbx/common/usbx_device_classes/inc
    ../../../../../../../middleware/usbx/common/usbx_device_classes/inc/: ux_device_class_dfu.h
  group middleware/usbx/common/usbx_device_classes/src
    ../../../../../../../middleware/usbx/common/usbx_device_classes/src/: ux_device_class_dfu_activate.c ux_device_class_dfu_control_request.c ux_device_class_dfu_deactivate.c ux_device_class_dfu_entry.c ux_device_class_dfu_initialize.c ux_device_class_dfu_state_get.c ux_device_class_dfu_state_sync.c ux_device_class_dfu_tasks_run.c ux_device_class_dfu_uninitialize.c
  group middleware/usbx/interfaces/usbx_stm32_device_controllers
    ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_initialize.c ux_dcd_stm32_register_callback.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c ux_dcd_stm32.h
  group middleware/usbx/interfaces/usbx_stm32_device_descriptors
    ../../../../../../../middleware/usbx/interfaces/usbx_stm32_device_descriptors/: ux_stm32_device_descriptors.c ux_stm32_device_descriptors.h
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32h7pxx_dfp
    ../../../../../../../stm32h7pxx_dfp/: README.md
  group stm32h7pxx_dfp/Include
    ../../../../../../../stm32h7pxx_dfp/Include/: stm32h7pxx.h
  group stm32h7pxx_drivers
    ../../../../../../../stm32h7pxx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32h7pxx_drivers/doc
    ../../../../../../../stm32h7pxx_drivers/doc/: STMicroelectronics.stm32h7pxx_hal_drivers_dependencies.md
  group stm32h7pxx_drivers/hal
    ../../../../../../../stm32h7pxx_drivers/hal/: stm32_hal.h stm32h7pxx_hal_cortex.c stm32h7pxx_hal_cortex.h stm32h7pxx_hal_def.h stm32h7pxx_hal_dma.c stm32h7pxx_hal_dma.h stm32h7pxx_hal_flash_itf.c stm32h7pxx_hal_flash_itf.h stm32h7pxx_hal_flash.c stm32h7pxx_hal_flash.h stm32h7pxx_hal_gpio.c stm32h7pxx_hal_gpio.h stm32h7pxx_hal_i2c.c stm32h7pxx_hal_i2c.h stm32h7pxx_hal_iwdg.c stm32h7pxx_hal_iwdg.h stm32h7pxx_hal_pcd.c stm32h7pxx_hal_pcd.h stm32h7pxx_hal_pwr.c stm32h7pxx_hal_pwr.h stm32h7pxx_hal_q.c stm32h7pxx_hal_q.h stm32h7pxx_hal_rcc.c stm32h7pxx_hal_rcc.h stm32h7pxx_hal_sbs.c stm32h7pxx_hal_sbs.h stm32h7pxx_hal_spi.c stm32h7pxx_hal_spi.h stm32h7pxx_hal_uart.c stm32h7pxx_hal_uart.h stm32h7pxx_hal.c stm32h7pxx_hal.h stm32h7pxx_usb_core_def.h stm32h7pxx_usb_otg_core.c stm32h7pxx_usb_otg_core.h
  group stm32h7pxx_drivers/ll
    ../../../../../../../stm32h7pxx_drivers/ll/: stm32h7pxx_ll_bus.h stm32h7pxx_ll_dma.h stm32h7pxx_ll_exti.h stm32h7pxx_ll_flash.h stm32h7pxx_ll_gpio.h stm32h7pxx_ll_i2c.h stm32h7pxx_ll_iwdg.h stm32h7pxx_ll_pwr.h stm32h7pxx_ll_rcc.h stm32h7pxx_ll_sbs.h stm32h7pxx_ll_spi.h stm32h7pxx_ll_usart.h stm32h7pxx_ll_utils.h
  group user_modifiable/Device/STM32H7P5IIK6
    ../../user_modifiable/Device/STM32H7P5IIK6/: startup_stm32h7p5xx.c system_stm32h7pxx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hsp_engine_fir_seq.ewp</path>
    </project>
</workspace>
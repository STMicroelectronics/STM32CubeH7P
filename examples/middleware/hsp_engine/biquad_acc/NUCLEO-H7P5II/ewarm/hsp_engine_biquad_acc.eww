<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hsp_engine_biquad_acc.ewp</path>
    </project>
</workspace>
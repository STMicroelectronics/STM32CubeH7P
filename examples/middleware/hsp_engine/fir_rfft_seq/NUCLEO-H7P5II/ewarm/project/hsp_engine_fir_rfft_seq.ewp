# IAR project hsp_engine_fir_rfft_seq.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32H7P5II ST STM32H7P5II
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7P5xx; USE_HSP_PROCLIST=1; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_NUCLEO-H7P5II/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/hsp_engine/common/core; ../../../../../../../middleware/hsp_engine/common/core/legacy; ../../../../../../../middleware/hsp_engine/common/modules; ../../../../../../../middleware/hsp_engine/common/modules/direct_lib; ../../../../../../../middleware/hsp_engine/common/modules/firmware; ../../../../../../../middleware/hsp_engine/common/modules/firmware/crom_1_1_10/cram_1_7; ../../../../../../../middleware/hsp_engine/common/modules/proclist_lib; ../../../../../../../middleware/hsp_engine/common/monitoring; ../../../../../../../middleware/hsp_engine/common/proclist; ../../../../../../../middleware/hsp_engine/common/utilities; ../../../../../../../middleware/hsp_engine/interfaces; ../../../../../../../middleware/hsp_engine/interfaces/services; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32h7pxx_dfp/Include; ../../../../../../../stm32h7pxx_drivers/hal; ../../../../../../../stm32h7pxx_drivers/ll; ../../../../../../../stm32h7pxx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/middleware; ../../generated/parts/led; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_NUCLEO-H7P5II
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: STM32H7P5xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32H7P5IIK6/stm32h7p5xi_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_hpdma1_ch0.c mx_hpdma1_ch0.h mx_hpdma1_ch15.c mx_hpdma1_ch15.h mx_hsp1.c mx_hsp1.h mx_pwr.c mx_pwr.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_usart2.c mx_usart2.h stm32_external_env.h stm32_ll.h stm32h7pxx_hal_conf.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group middleware/hsp_engine
    ../../../../../../../middleware/hsp_engine/: README.md
  group middleware/hsp_engine/common/core
    ../../../../../../../middleware/hsp_engine/common/core/: hsp_bram.c hsp_core.c
  group middleware/hsp_engine/common/modules/direct_lib
    ../../../../../../../middleware/hsp_engine/common/modules/direct_lib/: hsp_direct_command.c
  group middleware/hsp_engine/common/modules/firmware/crom_1_1_10/cram_1_7
    ../../../../../../../middleware/hsp_engine/common/modules/firmware/crom_1_1_10/cram_1_7/: hsp_fw_ram.c
  group middleware/hsp_engine/common/modules/proclist_lib
    ../../../../../../../middleware/hsp_engine/common/modules/proclist_lib/: hsp_proclist_complex.c hsp_proclist_conditional.c hsp_proclist_filter.c hsp_proclist_matrix.c hsp_proclist_scalar.c hsp_proclist_transform.c hsp_proclist_vector.c
  group middleware/hsp_engine/common/monitoring
    ../../../../../../../middleware/hsp_engine/common/monitoring/: hsp_monitoring.c
  group middleware/hsp_engine/common/proclist
    ../../../../../../../middleware/hsp_engine/common/proclist/: hsp_proclist.c
  group middleware/hsp_engine/common/utilities
    ../../../../../../../middleware/hsp_engine/common/utilities/: hsp_memcpy.c
  group middleware/hsp_engine/common/utilities/portable/IAR
    ../../../../../../../middleware/hsp_engine/common/utilities/portable/IAR/: st_hsp_memcpy32.s
  group middleware/hsp_engine/interfaces
    ../../../../../../../middleware/hsp_engine/interfaces/: hsp_bram_if.c hsp_hw_if.c
  group middleware/hsp_engine/interfaces/services
    ../../../../../../../middleware/hsp_engine/interfaces/services/: hsp_services.c
  group middleware_codegen
    ../../generated/middleware/: hsp_conf.h hsp_engine_rsrc_map.h mx_app_hsp_engine_bram_alloc.c mx_app_hsp_engine_bram_alloc.h mx_app_hsp_engine_process.c mx_app_hsp_engine_process.h mx_app_hsp_engine_seq.c mx_app_hsp_engine_seq.h mx_hsp_engine_app.c mx_hsp_engine_app.h
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32h7pxx_dfp
    ../../../../../../../stm32h7pxx_dfp/: README.md
  group stm32h7pxx_dfp/Include
    ../../../../../../../stm32h7pxx_dfp/Include/: stm32h7pxx.h
  group stm32h7pxx_drivers
    ../../../../../../../stm32h7pxx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32h7pxx_drivers/doc
    ../../../../../../../stm32h7pxx_drivers/doc/: STMicroelectronics.stm32h7pxx_hal_drivers_dependencies.md
  group stm32h7pxx_drivers/hal
    ../../../../../../../stm32h7pxx_drivers/hal/: stm32_hal.h stm32h7pxx_hal_cortex.c stm32h7pxx_hal_cortex.h stm32h7pxx_hal_def.h stm32h7pxx_hal_dma.c stm32h7pxx_hal_dma.h stm32h7pxx_hal_exti.c stm32h7pxx_hal_exti.h stm32h7pxx_hal_flash_itf.c stm32h7pxx_hal_flash_itf.h stm32h7pxx_hal_flash.c stm32h7pxx_hal_flash.h stm32h7pxx_hal_gpio.c stm32h7pxx_hal_gpio.h stm32h7pxx_hal_hsp.c stm32h7pxx_hal_hsp.h stm32h7pxx_hal_pwr.c stm32h7pxx_hal_pwr.h stm32h7pxx_hal_q.c stm32h7pxx_hal_q.h stm32h7pxx_hal_rcc.c stm32h7pxx_hal_rcc.h stm32h7pxx_hal_uart.c stm32h7pxx_hal_uart.h stm32h7pxx_hal.c stm32h7pxx_hal.h
  group stm32h7pxx_drivers/ll
    ../../../../../../../stm32h7pxx_drivers/ll/: stm32h7pxx_ll_bus.h stm32h7pxx_ll_dma.h stm32h7pxx_ll_exti.h stm32h7pxx_ll_flash.h stm32h7pxx_ll_gpio.h stm32h7pxx_ll_pwr.h stm32h7pxx_ll_rcc.h stm32h7pxx_ll_sbs.h stm32h7pxx_ll_usart.h stm32h7pxx_ll_utils.h
  group user_modifiable/Device/STM32H7P5IIK6
    ../../user_modifiable/Device/STM32H7P5IIK6/: startup_stm32h7p5xx.c system_stm32h7pxx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c

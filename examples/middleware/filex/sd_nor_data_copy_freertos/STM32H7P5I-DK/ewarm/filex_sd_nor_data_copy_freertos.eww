<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\filex_sd_nor_data_copy_freertos.ewp</path>
    </project>
</workspace>
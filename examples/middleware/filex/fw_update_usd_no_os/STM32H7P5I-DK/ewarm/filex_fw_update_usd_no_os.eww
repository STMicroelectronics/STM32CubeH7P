<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\filex_fw_update_usd_no_os.ewp</path>
    </project>
</workspace>
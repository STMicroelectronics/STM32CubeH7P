<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\hal_rng_additional_health_test_config.ewp</path>
    </project>
</workspace>
# IAR project hal_fmac_iir_it_to_dac_dma.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32H7P5II ST STM32H7P5II
  General.FPU2: 7
  ICCARM.CCDefines: COEFF_VECTOR_A_SIZE=6; COEFF_VECTOR_B_SIZE=7; MX_DAC_CHANNEL=HAL_DAC_CHANNEL_1; STM32H7P5xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../user_modifiable/_release_IAR_STM32H7P5I-DK/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../arch/cmsis_dsp/Include; ../../../../../../../arch/cmsis_dsp/PrivateInclude; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32h7pxx_dfp/Include; ../../../../../../../stm32h7pxx_drivers/hal; ../../../../../../../stm32h7pxx_drivers/ll; ../../../../../../../stm32h7pxx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/hal; ../../generated/parts/led; ../../generated/utilities/basic_stdio; ../../user_modifiable/_release_IAR_STM32H7P5I-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32H7P5xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32H7P5IIK6Q/stm32h7p5xi_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group arch/cmsis_dsp/Include
    ../../../../../../../arch/cmsis_dsp/Include/: arm_common_tables_f16.h arm_common_tables.h arm_const_structs_f16.h arm_const_structs.h arm_math_f16.h arm_math.h
  group arch/cmsis_dsp/Source/BasicMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group arch/cmsis_dsp/Source/BayesFunctions
    ../../../../../../../arch/cmsis_dsp/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group arch/cmsis_dsp/Source/CommonTables
    ../../../../../../../arch/cmsis_dsp/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group arch/cmsis_dsp/Source/ComplexMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group arch/cmsis_dsp/Source/ControllerFunctions
    ../../../../../../../arch/cmsis_dsp/Source/ControllerFunctions/: ControllerFunctions.c
  group arch/cmsis_dsp/Source/DistanceFunctions
    ../../../../../../../arch/cmsis_dsp/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
  group arch/cmsis_dsp/Source/FastMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group arch/cmsis_dsp/Source/FilteringFunctions
    ../../../../../../../arch/cmsis_dsp/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group arch/cmsis_dsp/Source/InterpolationFunctions
    ../../../../../../../arch/cmsis_dsp/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group arch/cmsis_dsp/Source/MatrixFunctions
    ../../../../../../../arch/cmsis_dsp/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group arch/cmsis_dsp/Source/QuaternionMathFunctions
    ../../../../../../../arch/cmsis_dsp/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
  group arch/cmsis_dsp/Source/StatisticsFunctions
    ../../../../../../../arch/cmsis_dsp/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group arch/cmsis_dsp/Source/SupportFunctions
    ../../../../../../../arch/cmsis_dsp/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group arch/cmsis_dsp/Source/SVMFunctions
    ../../../../../../../arch/cmsis_dsp/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group arch/cmsis_dsp/Source/TransformFunctions
    ../../../../../../../arch/cmsis_dsp/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group arch/cmsis_dsp/Source/WindowFunctions
    ../../../../../../../arch/cmsis_dsp/Source/WindowFunctions/: WindowFunctions.c
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_cortex_scb.c mx_cortex_scb.h mx_dac1.c mx_dac1.h mx_def.h mx_fmac1.c mx_fmac1.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_pwr.c mx_pwr.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_tim6.c mx_tim6.h mx_usart2.c mx_usart2.h stm32_external_env.h stm32h7pxx_hal_conf.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group generated/utilities/basic_stdio
    ../../generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32h7pxx_dfp
    ../../../../../../../stm32h7pxx_dfp/: README.md
  group stm32h7pxx_dfp/Include
    ../../../../../../../stm32h7pxx_dfp/Include/: stm32h7pxx.h
  group stm32h7pxx_drivers
    ../../../../../../../stm32h7pxx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32h7pxx_drivers/doc
    ../../../../../../../stm32h7pxx_drivers/doc/: STMicroelectronics.stm32h7pxx_hal_drivers_dependencies.md
  group stm32h7pxx_drivers/hal
    ../../../../../../../stm32h7pxx_drivers/hal/: stm32_hal.h stm32h7pxx_hal_cortex.c stm32h7pxx_hal_cortex.h stm32h7pxx_hal_dac.c stm32h7pxx_hal_dac.h stm32h7pxx_hal_def.h stm32h7pxx_hal_dma.c stm32h7pxx_hal_dma.h stm32h7pxx_hal_flash_itf.c stm32h7pxx_hal_flash_itf.h stm32h7pxx_hal_fmac.c stm32h7pxx_hal_fmac.h stm32h7pxx_hal_gpio.c stm32h7pxx_hal_gpio.h stm32h7pxx_hal_pwr.c stm32h7pxx_hal_pwr.h stm32h7pxx_hal_q.c stm32h7pxx_hal_q.h stm32h7pxx_hal_rcc.c stm32h7pxx_hal_rcc.h stm32h7pxx_hal_sbs.c stm32h7pxx_hal_sbs.h stm32h7pxx_hal_tim.c stm32h7pxx_hal_tim.h stm32h7pxx_hal_uart.c stm32h7pxx_hal_uart.h stm32h7pxx_hal.c stm32h7pxx_hal.h
  group stm32h7pxx_drivers/ll
    ../../../../../../../stm32h7pxx_drivers/ll/: stm32h7pxx_ll_bus.h stm32h7pxx_ll_dac.h stm32h7pxx_ll_dma.h stm32h7pxx_ll_exti.h stm32h7pxx_ll_flash.h stm32h7pxx_ll_fmac.h stm32h7pxx_ll_gpio.h stm32h7pxx_ll_pwr.h stm32h7pxx_ll_rcc.h stm32h7pxx_ll_sbs.h stm32h7pxx_ll_tim.h stm32h7pxx_ll_usart.h stm32h7pxx_ll_utils.h
  group user_modifiable/Device/STM32H7P5IIK6Q
    ../../user_modifiable/Device/STM32H7P5IIK6Q/: startup_stm32h7p5xx.c system_stm32h7pxx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c

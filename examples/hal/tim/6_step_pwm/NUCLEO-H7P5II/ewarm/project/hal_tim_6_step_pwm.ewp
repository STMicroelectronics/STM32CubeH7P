# IAR project hal_tim_6_step_pwm.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32H7P5II ST STM32H7P5II
  General.FPU2: 7
  ICCARM.CCDefines: MX_PULSE_X=16; MX_PULSE_Y=8; MX_PULSE_Z=4; MX_PWM_CHANNEL_X=HAL_TIM_CHANNEL_1; MX_PWM_CHANNEL_XN=HAL_TIM_CHANNEL_1N; MX_PWM_CHANNEL_Y=HAL_TIM_CHANNEL_2; MX_PWM_CHANNEL_YN=HAL_TIM_CHANNEL_2N; MX_PWM_CHANNEL_Z=HAL_TIM_CHANNEL_3; MX_PWM_CHANNEL_ZN=HAL_TIM_CHANNEL_3N; STM32H7P5xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32h7pxx_dfp/Include; ../../../../../../../stm32h7pxx_drivers/hal; ../../../../../../../stm32h7pxx_drivers/ll; ../../../../../../../stm32h7pxx_drivers/timebases; ../../../application; ../../generated/hal; ../../generated/parts/led; ../../user_modifiable/_release_IAR_NUCLEO-H7P5II
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32H7P5xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../user_modifiable/Device/STM32H7P5IIK6/stm32h7p5xi_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group generated/hal
    ../../generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_cortex_scb.c mx_cortex_scb.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_pwr.c mx_pwr.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_tim8.c mx_tim8.h stm32h7pxx_hal_conf.h
  group generated/parts/led
    ../../generated/parts/led/: mx_led.h
  group part_drivers/led
    ../../../../../../../part_drivers/led/: README.md SW_Security_Level.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32h7pxx_dfp
    ../../../../../../../stm32h7pxx_dfp/: README.md
  group stm32h7pxx_dfp/Include
    ../../../../../../../stm32h7pxx_dfp/Include/: stm32h7pxx.h
  group stm32h7pxx_drivers
    ../../../../../../../stm32h7pxx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32h7pxx_drivers/doc
    ../../../../../../../stm32h7pxx_drivers/doc/: STMicroelectronics.stm32h7pxx_hal_drivers_dependencies.md
  group stm32h7pxx_drivers/hal
    ../../../../../../../stm32h7pxx_drivers/hal/: stm32_hal.h stm32h7pxx_hal_cortex.c stm32h7pxx_hal_cortex.h stm32h7pxx_hal_def.h stm32h7pxx_hal_dma.c stm32h7pxx_hal_dma.h stm32h7pxx_hal_flash_itf.c stm32h7pxx_hal_flash_itf.h stm32h7pxx_hal_gpio.c stm32h7pxx_hal_gpio.h stm32h7pxx_hal_pwr.c stm32h7pxx_hal_pwr.h stm32h7pxx_hal_q.c stm32h7pxx_hal_q.h stm32h7pxx_hal_rcc.c stm32h7pxx_hal_rcc.h stm32h7pxx_hal_sbs.c stm32h7pxx_hal_sbs.h stm32h7pxx_hal_tim.c stm32h7pxx_hal_tim.h stm32h7pxx_hal.c stm32h7pxx_hal.h
  group stm32h7pxx_drivers/ll
    ../../../../../../../stm32h7pxx_drivers/ll/: stm32h7pxx_ll_bus.h stm32h7pxx_ll_dma.h stm32h7pxx_ll_exti.h stm32h7pxx_ll_flash.h stm32h7pxx_ll_gpio.h stm32h7pxx_ll_pwr.h stm32h7pxx_ll_rcc.h stm32h7pxx_ll_sbs.h stm32h7pxx_ll_tim.h stm32h7pxx_ll_utils.h
  group user_modifiable/Device/STM32H7P5IIK6
    ../../user_modifiable/Device/STM32H7P5IIK6/: startup_stm32h7p5xx.c system_stm32h7pxx.c
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md

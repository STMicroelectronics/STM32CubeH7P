<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\st7315_display_image.ewp</path>
    </project>
</workspace>
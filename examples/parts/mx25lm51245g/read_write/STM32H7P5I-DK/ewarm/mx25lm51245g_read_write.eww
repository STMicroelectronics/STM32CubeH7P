<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\mx25lm51245g_read_write.ewp</path>
    </project>
</workspace>